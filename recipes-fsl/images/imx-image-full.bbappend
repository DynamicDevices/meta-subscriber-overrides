
CORE_IMAGE_EXTRA_INSTALL += " \
    kernel-module-tas2563 \
    dotnet \
"

#    kernel-module-nxp-wlan \
#
